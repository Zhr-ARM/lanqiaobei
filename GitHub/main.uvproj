# Keil uVision project main.uvproj, settings and files
target 2011 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\driver
  group user
    ./: STARTUP.A51 main.c
  group driver
    ../driver/: I2C.c key.c Onewire.c relay.c smg.c
